# Keil uVision project TouchPad.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TouchPad
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./: main.c interrupt.c
  group Driver
    ./: gpio.c rcc.c timer.c exti.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.5.0
